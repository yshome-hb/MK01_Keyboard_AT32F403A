# Keil uVision project MK01_Keyboard.uvprojx, settings and files
target Rotary_Controller (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ACCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Rotary_Controller +hex
  AfterMake: fromelf.exe --bin --output ..\Output\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: AT32F403ACCT7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\FWlib\inc;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\User;..\MIddleware\FreeRTOS\include;..\MIddleware\FreeRTOS\portable\RVDS\ARM_CM4F;..\MIddleware\FreeRTOS-Plus-CLI\include;..\Drivers\inc;..\Device;..\Device\util;..\MIddleware\AT32_USB-FS-Device_Driver\inc;..\App;..\App\USB_Device_Port;..\App\handler;..\App\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Main
    ../User/: main.c at32f4xx_it.c
  group BSP
    ../Drivers/src/: debug.c delay.c output.c input.c ota.c flash.c sys.c
  group CMSIS
    ../User/: system_at32f4xx.c
    ../CMSIS/DeviceSupport/startup/mdk/: startup_at32f403acct7.s
  group AT32_FWLIB
    ../FWlib/src/: at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c at32f4xx_acc.c
  group FreeRTOS
    ../MIddleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MIddleware/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../MIddleware/FreeRTOS/portable/MemMang/: heap_4.c
  group USB-FS-Device-Driver
    ../MIddleware/AT32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-Device-Port
    ../App/USB_Device_Port/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_config.c
  group Device
    ../Device/: arch_init.c arch_os.c
