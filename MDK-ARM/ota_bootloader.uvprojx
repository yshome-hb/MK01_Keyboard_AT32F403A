# Keil uVision project ota_bootloader.uvprojx, settings and files
target OTA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ACCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTA_Bootloader +hex
  AfterMake: fromelf.exe --bin --output ..\Output\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ACCT7,LIBRARY_VERSION
  c include: ..\FWlib\inc;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\OTA_Bootloader;..\Drivers\inc;..\MIddleware\FreeRTOS\include;..\MIddleware\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ../OTA_Bootloader/: main.c at32f4xx_it.c iap_task.c
  group CMSIS
    ../OTA_Bootloader/: system_at32f4xx.c
    ../CMSIS/DeviceSupport/startup/mdk/: startup_at32f403acct7.s
  group AT32_FWLIB
    ../FWlib/src/: at32f4xx_flash.c at32f4xx_gpio.c misc.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c
  group BSP
    ../Drivers/src/: flash.c ota.c sys.c delay.c output.c usart.c timer.c
  group FreeRTOS
    ../MIddleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MIddleware/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../MIddleware/FreeRTOS/portable/MemMang/: heap_3.c
